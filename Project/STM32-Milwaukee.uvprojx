# Keil uVision project STM32-Milwaukee.uvprojx, settings and files
target STM32-Milwaukee (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MKE_V02 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\Libraries\FWlib\inc;..\Libraries\FWlib\src;..\Libraries\CMSIS;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group FWLIB
    ../Libraries/FWlib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_adc.c stm32f0xx_usart.c stm32f0xx_exti.c stm32f0xx_pwr.c stm32f0xx_syscfg.c stm32f0xx_flash.c
  group USER
    ../User/: main.c main.h stm32f0xx_it.c key.c key.h time.c time.h system_stm32f0xx.c ADC.c ADC.h common.c common.h LD.c LD.h pin_mcu.h I2C.c I2C.h Charging.c Charging.h usart.c usart.h GPIO.c GPIO.h Flash.c Flash.h Sensor_I2C.c Sensor_I2C.h Task.c Task.h
